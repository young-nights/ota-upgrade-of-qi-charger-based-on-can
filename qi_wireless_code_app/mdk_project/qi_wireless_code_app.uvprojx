# Keil uVision project qi_wireless_code_app.uvprojx, settings and files
target qi_wireless_code_app (6190000::V6.19::ARMCLANG)
  device: AT32F426KBU7-4 ArteryTek
  pack: ArteryTek.AT32F422_426_DFP.2.0.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08004100,0xBF00) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: qi_wireless_code_app
  AfterMake: fromelf --bin --output="$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c misc: -Wno-padded -Wno-sign-conversion -Wno-covered-switch-default -Wno-missing-noreturn -Wno-bitfield-enum-conversion -Wno-cast-qual -Wno-extra-semi-stmt -Wno-invalid-utf8 -Wno-implicit-int-conversion
  c include: ..\libraries\drivers\inc;..\mdk_app\Inc;..\mdk_user\Inc;..\libraries\cmsis\core_support;..\libraries\cmsis\device_support\startup;..\libraries\cmsis\device_support;..\mdk_can\Inc
  memory RVCT4: ROM 0x8003100 size 0xcf00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../libraries/cmsis/device_support/startup/: startup_at32f422_426.s
  group CMSIS
    ../mdk_user/Src/: system_at32f422_426.c
  group mdk_lib
    ../libraries/drivers/src/: at32f422_426_adc.c at32f422_426_can.c at32f422_426_cmp.c at32f422_426_crc.c at32f422_426_crm.c at32f422_426_debug.c at32f422_426_dma.c at32f422_426_ertc.c at32f422_426_exint.c at32f422_426_flash.c at32f422_426_gpio.c at32f422_426_i2c.c at32f422_426_misc.c at32f422_426_pwc.c at32f422_426_scfg.c at32f422_426_spi.c at32f422_426_tmr.c at32f422_426_usart.c at32f422_426_wdt.c at32f422_426_wwdt.c
  group mdk_user
    ../mdk_user/Src/: at32f422_426_clock.c at32f422_426_int.c main.c
  group mdk_app
    ../mdk_app/Src/: can_protocol.c ota_trigger.c ota_download.c qi_uart.c qi_uart_sniff.c qi_protocol.c timer_drv.c nvm_drv.c isotp.c lifecycle.c device_info.c board_gpio.c sit1145.c sha256.c uECC.c
  group mdk_can
    ../mdk_can/Src/: can_driver.c
